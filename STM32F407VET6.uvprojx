# Keil uVision project STM32F407VET6.uvprojx, settings and files
target STM32F407VET6 (6220000::V6.22::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VET6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Hardware;.\Hardware\LCD;.\Hardware\OLED;.\Hardware\OLED\Menu;.\System;.\U8g2;.\LVGL;.\Util
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c task.c msp.c interrupt.c sysclock.c
  group Hardware
    ./Hardware/LCD/: LCD.c LCD.h LCD_Font.h Touch.c Touch.h
    ./Hardware/OLED/: OLED.c OLED.h OLED_Font.h
    ./Hardware/: Key.c Key.h LED.c LED.h
    ./Hardware/OLED/Menu/: Menu.c Menu.h
  group System
    ./System/: ADC.c ADC.h DAC.c DAC.h DMA.c DMA.h GPIO.c GPIO.h RNG.c RNG.h sys.h TIM.c TIM.h
  group Util
    ./Util/: Delay.c Delay.h Encoder.c Encoder.h PWM.c PWM.h Serial.c Serial.h Signal.c Signal.h Timer.c Timer.h
  group U8g2
    ./U8g2/: mui.c mui.h mui_u8g2.c mui_u8g2.h u8g2.c u8g2.h u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8.h u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group LVGL
    ./LVGL/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.1.0, RTOS:Config 11.1.0, RTOS:Core 11.1.0, RTOS:Event Groups 11.1.0, RTOS:Heap 11.1.0, RTOS:Timers 11.1.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:CAN 1.8.1, Device:STM32Cube HAL:CRC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DAC 1.8.1, Device:STM32Cube HAL:DCMI 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:ETH 1.8.1, Device:STM32Cube HAL:EXTI 1.8.1, Device:STM32Cube HAL:Flash 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:HCD 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:I2S 1.8.1, Device:STM32Cube HAL:IRDA 1.8.1, Device:STM32Cube HAL:IWDG 1.8.1, Device:STM32Cube HAL:MMC 1.8.1, Device:STM32Cube HAL:NAND 1.8.1, Device:STM32Cube HAL:NOR 1.8.1, Device:STM32Cube HAL:PC Card 1.8.1, Device:STM32Cube HAL:PCD 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:RNG 1.8.1, Device:STM32Cube HAL:RTC 1.8.1, Device:STM32Cube HAL:SD 1.8.1, Device:STM32Cube HAL:SMBUS 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:SRAM 1.8.1, Device:STM32Cube HAL:Smartcard 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:STM32Cube HAL:WWDG 1.8.1, Device:Startup 2.6.3, LVGL:lvgl:Essential 8.4.0, LVGL:lvgl:Porting 8.4.0
